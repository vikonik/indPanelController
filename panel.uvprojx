# Keil uVision project panel.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: panel
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_MDR1986VE1T
  c misc: --cpp11
  c include: .\User;..\CPP_lib\RCC;..\CPP_lib\LedInd;..\CPP_lib\Port;..\CPP_lib\Delay;.\Interrupt;..\CPP_lib\ADC;..\CPP_lib\UART;..\CPP_lib\Timer
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  group user
    ./user/: main.cpp portMaping.h HAL.cpp HAL.h
  group RCC
    ../CPP_lib/RCC/: RCC.cpp RCC.h
  group LedInd
    ../CPP_lib/LedInd/: ledInd.cpp ledInd.h
  group Port
    ../CPP_lib/Port/: port.cpp port.h
  group Timer
    ../CPP_lib/Timer/: timer.cpp timer.h
  group Delay
    ../CPP_lib/Delay/: delay.cpp delay.h
  group Interrupt
    ./Interrupt/: MDR32F9Qx_it.h MDR32F9Qx_it.cpp
  group ADC
    ../CPP_lib/ADC/: ADC.cpp ADC.h
  group Uart
    ../CPP_lib/UART/: uart.cpp uart.h
software components: Device:Startup 1.5, Drivers:ADC 1.5, Drivers:PORT 1.5, Drivers:RST_CLK 1.5, Drivers:SSP 1.5, Drivers:TIMER 1.5, Drivers:UART 1.5
